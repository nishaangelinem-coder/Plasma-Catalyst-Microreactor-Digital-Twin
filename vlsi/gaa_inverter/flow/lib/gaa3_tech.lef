VERSION 5.8 ;
BUSBITCHARS "[]" ; DIVIDERCHAR "/" ;
UNITS DATABASE MICRONS 1000 ; END UNITS
MANUFACTURINGGRID 0.001 ;
SITE gaa3_core CLASS CORE ; SYMMETRY Y ; SIZE 0.048 BY 0.168 ; END gaa3_core
LAYER M1 TYPE ROUTING ; DIRECTION VERTICAL ; PITCH 0.028 ; WIDTH 0.016 ; SPACING 0.012 ; RESISTANCE RPERSQ 22 ; CAPACITANCE CPERSQDIST 0.0003 ; END M1
LAYER V1 TYPE CUT ; SPACING 0.012 ; WIDTH 0.010 ; RESISTANCE 35 ; END V1
LAYER M2 TYPE ROUTING ; DIRECTION HORIZONTAL ; PITCH 0.028 ; WIDTH 0.016 ; SPACING 0.012 ; RESISTANCE RPERSQ 18 ; CAPACITANCE CPERSQDIST 0.00018 ; END M2
LAYER V2 TYPE CUT ; SPACING 0.012 ; WIDTH 0.010 ; RESISTANCE 30 ; END V2
LAYER M3 TYPE ROUTING ; DIRECTION VERTICAL ; PITCH 0.028 ; WIDTH 0.016 ; SPACING 0.012 ; RESISTANCE RPERSQ 15 ; END M3
LAYER V3 TYPE CUT ; SPACING 0.014 ; WIDTH 0.012 ; RESISTANCE 25 ; END V3
LAYER M4 TYPE ROUTING ; DIRECTION HORIZONTAL ; PITCH 0.036 ; WIDTH 0.020 ; SPACING 0.016 ; RESISTANCE RPERSQ 12 ; END M4
VIA V1_M1M2 DEFAULT LAYER M1 ; RECT -0.008 -0.008 0.008 0.008 ; LAYER V1 ; RECT -0.005 -0.005 0.005 0.005 ; LAYER M2 ; RECT -0.008 -0.008 0.008 0.008 ; END V1_M1M2
VIA V2_M2M3 DEFAULT LAYER M2 ; RECT -0.008 -0.008 0.008 0.008 ; LAYER V2 ; RECT -0.005 -0.005 0.005 0.005 ; LAYER M3 ; RECT -0.008 -0.008 0.008 0.008 ; END V2_M2M3
END LIBRARY
